# Keil uVision project app.uvprojx, settings and files
target Release (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf --bin -o build\app.bin build\app.axf
  c flags: uC99=1
  c include: ..\..\sdk\include;..\screen;..\res
  library: MicroLIB
  memory RVCT4: ROM 0x34000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\sdk\lib\juma_sdk.sct
  group Application
    ../: app.c stop.c start.c normal.c timer.c train1.c train2.c train3.c train4.c count.c model_contral.c light.c jump.h
  group Library
    ../../sdk/lib/: juma_sdk.lib
    ../screen/: ssd1306.c
    ../res/: Helvetica_16.c
software components: CMSIS:CORE 4.1.0, nRF_Drivers:nrf_gpio 3.0.0
